# Keil uVision project template.uvprojx, settings and files
target STM32F4x1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F401RCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F401xx
  c include: ..\MDK-ARM;..\Core\Inc;..\Drivers\STM32F4xx_StdPeriph_Driver\inc;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Middlewares\delay;..\Middlewares\gpio;..\Middlewares\tim;..\Middlewares\usart;..\Middlewares\motor;..\Middlewares;..\Middlewares\I2C;..\SYSTEM\delay;..\SYSTEM\sys;..\Middlewares\MPU6050;..\Middlewares\MPU6050\DMP;..\Middlewares\MS5611;..\FreeRTOS\include;..\FreeRTOS\port\MemMang;..\FreeRTOS\port\RVDS\ARM_CM4F;..\FreeRTOS;..\Task;..\Middlewares\LED
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User/Core
    ../Core/Src/: main.c stm32f4xx_it.c system_stm32f4xx.c Gfly.c
    ../FreeRTOS/: FreeRTOSConfig.h
  group MDK-ARM
    ./: startup_stm32f411xe.s
  group Drivers/STM32F4xx_StdPeriph_Driver
    ../Drivers/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group HARDWARE
    ../Middlewares/usart/: usart.c
    ../Middlewares/motor/: motor.c
    ../Middlewares/LED/: led.c
  group MPU6050
    ../Middlewares/MPU6050/: mpu6050.c iic.c
    ../Middlewares/MPU6050/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group MS5611
    ../Middlewares/MS5611/: ms5611.c
  group FreeRTOS/src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Freertos/port
    ../FreeRTOS/port/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/port/MemMang/: heap_4.c
  group TASK
    ../Task/: MainFlyTask.c UsartTask.c SeniorTask.c GflyConfig.h
software components: CMSIS:CORE 4.3.0
